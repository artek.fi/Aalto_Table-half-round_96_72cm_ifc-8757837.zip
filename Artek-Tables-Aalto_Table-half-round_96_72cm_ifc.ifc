Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-11-23T02:50:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 23 02:50:07 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\4cd241f8-d850-4ce6-8a37-90f0a535371d\c0e60141-6b06-4813-ae68-ab7cfae8a922\ifc * Database version: 5507 * Database creation date: Thu Nov 23 02:50:06 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 23 02:50:06 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 23 02:50:06 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Aalto Table, half-round 96, 72cm, Artek-Tables-Aalto_Table-half-round_96_rfa:Aalto Table, half-round 96, 72cm:452434
In: Level 1
Type - Material: Natural laquered
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Height: Aalto_half-round_96_72
Type - General - Author: BIMstone; BIMObjectName: Artek-Tables-Aalto_Table-half-round_96; ManufacturerName: Artek; ManufacturerURL: https://www.artek.fi/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: The Aalto Table conveys a relaxed familiarity that resists categorisation. With legs and edge-bands of Finnish birch, it radiates natural beauty and warmth, moving easily between public and private spheres in accordance with Alvar Aalto’s conception of versatile furniture.; Revision: n/a; Uniclass2: Pr_40_50_21_21; Uniclass2015Description: Dining tables; Uniclass2015Reference: Pr_40_50_21_22; Version: 1; VersionDate: 16/11/2023
Type - Identity Data - Collection: Aalto; Cost: 0; Description: The Aalto Table conveys a relaxed familiarity that resists categorisation. With legs and edge-bands of Finnish birch, it radiates natural beauty and warmth, moving easily between public and private spheres in accordance with Alvar Aalto’s conception of versatile furniture.; Designer: Alvar Aalto, 1933; Manufacturer: Artek; Model: Aalto Table, half-round 96, 72cm; OmniClass Number: 23.40.20.14.17.11; OmniClass Title: Dining Room Tables; ProductDatasheet: https://www.artek.fi/downloads/Artek-Spaces-Brochure-2022_compressed.pdf; Type Name: Aalto Table, half-round 96, 72cm; URL: https://www.artek.fi/en/products/aalto-table-half-round
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Artek; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Artek-Tables-Aalto_Table-half-round_96_rfa; Features: n/a; Finish: The top is available in birch, linoleum, or laminate, materials that age gracefully over time and last across generations.; Grade: n/a; Material: Wood and laminate; ModelNumber: n/a; ModelReference: n/a; Name: Aalto_Table-half-round_96; ReplacementCost: n/a; Shape: Sculptured; Size: 750x750x720 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Artek
Type - Pset_ProductRequirements - Name: Aalto_Table-half-round_96; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Aalto Table, half-round 96, 72cm
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 2.74507 m2; Volume: 0.810033 m3
Materials and Finishes - TableMainMaterial: Natural laquered; TableSecondaryMaterial: Natural laquered
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Artek-Tables-Aalto_Table-half-round_96_rfa: Aalto Table, half-round 96, 72cm; Family and Type: Artek-Tables-Aalto_Table-half-round_96_rfa: Aalto Table, half-round 96, 72cm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Artek-Tables-Aalto_Table-half-round_96_rfa: Aalto Table, half-round 96, 72cm; Type Id: Artek-Tables-Aalto_Table-half-round_96_rfa: Aalto Table, half-round 96, 72cm; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
